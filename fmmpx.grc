options:
  parameters:
    author: Japser Leo
    generate_options: qt_gui
    id: fmmpx
    output_language: python
    title: fmmpx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.45'
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_1_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.45'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/liujiarun/大三下/通信系统建模与仿真/作业/wav文件/4.22Left 8000.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /Users/liujiarun/大三下/通信系统建模与仿真/作业/wav文件/4.22Right 8000.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '0.1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: 2R
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: 2L
  states: {state: disabled}
- name: note_0_0_0
  id: note
  parameters:
    note: L+R Bband
  states: {state: disabled}
- name: note_0_0_0_0
  id: note
  parameters:
    note: L-R Bband
  states: {state: disabled}
- name: note_0_0_0_1
  id: note
  parameters:
    note: L+R Bband
  states: {state: disabled}
- name: note_0_0_0_1_0
  id: note
  parameters:
    note: L-R @38 kHz
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"yellow"'
    color2: '"blue"'
    color3: '"red"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: L+R
    label2: L-R
    label3: P
    nconnections: '3'
    type: float
    width1: '3'
    width2: '2'
    width3: '4'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"yellow"'
    color2: '"blue"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: L+R
    label2: L-R
    nconnections: '2'
    type: float
    width1: '3'
    width2: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '5'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '5'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_2, '2']
- [analog_sig_source_x_0_0, '0', qtgui_freq_sink_x_1, '2']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_1_0, '0', audio_sink_0, '0']
- [blocks_add_xx_1_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_add_xx_1_0_0, '0', audio_sink_0_0, '0']
- [blocks_add_xx_1_0_0, '0', qtgui_freq_sink_x_1_0, '1']
- [blocks_add_xx_2, '0', band_pass_filter_0_0, '0']
- [blocks_add_xx_2, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_2, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_1_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_1_0, '1']
- [low_pass_filter_0_0, '0', blocks_add_xx_1_0_0, '1']
- [rational_resampler_xxx_0, '0', audio_sink_0_1_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0_1, '0']

metadata:
  file_format: 1
